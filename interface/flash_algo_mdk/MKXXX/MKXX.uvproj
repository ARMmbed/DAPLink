# Keil uVision project MKXX.uvproj, settings and files
target MKP128 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_P128
  c flags: Optim=3
  c define: MKP128
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c FlashPrg_new.c
  group Device Description
    ./: FlashDev.c
  group Flash Library
    ./C90TFS/drvsrc/source/: DEFlashPartition.c DFlashGetProtection.c DFlashSetProtection.c EEEWrite.c EERAMGetProtection.c EERAMSetProtection.c FlashCheckSum.c FlashCommandSequence.c FlashEraseAllBlock.c FlashEraseBlock.c FlashEraseResume.c FlashEraseSector.c FlashEraseSuspend.c FlashGetInterruptEnable.c FlashGetSecurityState.c FlashInit.c FlashProgramCheck.c FlashProgramLongword.c FlashProgramOnce.c FlashProgramSection.c FlashReadOnce.c FlashReadResource.c FlashSecurityBypass.c FlashSetInterruptEnable.c FlashVerifyAllBlock.c FlashVerifyBlock.c FlashVerifySection.c PFlashGetProtection.c PFlashSetProtection.c SetEEEEnable.c FlashProgramPhrase.c FlashEraseSector_Keil.c FlashProgramLongword_Keil.c
  group flash
    ./flash/: flash.h
    ./flash/src/: flash_command_sequence.c flash_densities.h flash_densities_k_series.c flash_densities_kl_series.c flash_erase.c flash_erase_all.c flash_erase_all_unsecure.c flash_features.h flash_get_property.c flash_get_security_state.c flash_init.c flash_is_protected.c flash_program.c flash_security_bypass.c flash_verify_erase.c flash_verify_erase_all.c flash_verify_program.c SSD_FTFx_Common.h
target MKP256 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_P256
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP256
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP256_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P256_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP256_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP512 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_P512
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP512
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP512_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P512_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP512_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP512X (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_P512X
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP512X
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP1024 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_P1M0
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP1024
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP1024
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP128_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P128_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP128_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP128_48MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P128_48MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP128_48MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP64 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_P64
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP64
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP64
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP64_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P64_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP64_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP64_48MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P64_48MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP64_48MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP32_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P32_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP32_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP32_48MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P32_48MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP32_48MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP16_48MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P16_48MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP16_48MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKP8_48MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_P8_48MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKP8_48MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD32 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_D32
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD32
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKD32
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD32_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_D32_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD32_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD32_72MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_D32_72MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD32_72MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD64_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MK_D64_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD64_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD128 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_D128
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD128
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKD128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD256 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_D256
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD256
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKD256
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKD512 (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_D512
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKD512
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKD512
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKPIFR (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_PIFR
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKPIFR
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKPIFR
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKPIFR_48MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKPIFR_48MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKPIFR_48MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKPIFR_48MHZ
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKPIFR_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKPIFR_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKPIFR_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKPIFR
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKPIFR_120MHZ (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MKPIFR_120MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKPIFR_120MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKPIFR_120MHZ
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKDIFR (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK_DIFR
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKDIFR
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKDIFR
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MKDIFR_50MHZ (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: MKDIFR_50MHZ
  AfterMake: cmd.exe /C copy ".\Output\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: MKDIFR_50MHZ
  c misc: --diag_suppress=1
  c include: .\C90TFS\drvsrc\include;..\..\INC\Freescale\Kinetis
  asm define: MKDIFR
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target MK64FN1M0_Pflash (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: MK64FN1M0
  c flags: Optim=4
  c define: MKP128 CPU_MK64FN1M0VMD12
  c misc: --diag_suppress=1 --gnu
  c include: .;.\include
  asm define: MKP128
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
