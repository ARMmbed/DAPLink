# Keil uVision project nRF51822AA.uvproj, settings and files
target nRF51822AA (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nRF51822AA_flash_algo
  c flags: Optim=3
  c include: ../
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
