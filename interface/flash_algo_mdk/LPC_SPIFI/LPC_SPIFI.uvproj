# Keil uVision project LPC_SPIFI.uvproj, settings and files
target LPC1800_SPIFI_4096 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: flash_algo
  c flags: Optim=3
  c define: LPC1800_SPIFI,LPC1800_4096,USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group SPIFI Lib
    ./: spifi_drv_PI.lib
target LPC1800_SPIFI_8192 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: flash_algo
  c flags: Optim=3
  c define: LPC1800_SPIFI,LPC1800_8192,USE_SPIFI_LIB
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
