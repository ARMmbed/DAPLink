# Keil uVision project k20d50m_interface.uvproj, settings and files
target mk20d5_k20d50m_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: mk20dx_kl05z_if
  c flags: Optim=3
  c define: TARGET_MK20D5, __RTX, DBG_K20D50M, BOARD_FRDM_K20D50M
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_K20D50M;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c board.c
    ../../Common/inc/: mbed_htm.h
  group HAL-Interface
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: DAP_config.h gpio.c read_uid.c uart.c usbd_MK20D5.c usb_buf.h
  group HAL-Target
    ../../target/hal/DBG_Freescale/DBG_KL05Z/: target_reset.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
target mk20d5_k20d50m_openSDA_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: as above
  output: k20dx128_kl05z_if_mbed
  AfterMake: %KARM\ARMCC\bin\fromelf --m32combined --output=".\mbed-Interface-v1-FRDM-K20D50M.S19" "#L"
  c flags: Optim=3
  c define: OFFSET_VTABLE_32K, TARGET_MK20D5, __RTX, DBG_K20D50M, BOARD_FRDM_K20D50M
  c misc: -DK20D50M
  c include: ..\..\Common\inc;..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\interface\cmsis;..\..\target\hal\DBG_Freescale\DBG_K20D50M;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x8000 size 0x12000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5_openSDA_bootloader.sct
