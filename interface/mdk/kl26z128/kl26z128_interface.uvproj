# Keil uVision project kl26z128_interface.uvproj, settings and files
target kl26z128_mbit_0x0000 (ARM-ADS)
  device: MKL26Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: kl26z128_mbit_0x0000
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  c flags: Optim=1
  c define: TARGET_MKL26Z, __RTX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_NordicSemi\DBG_nRF51822AA;..\..\interface\hal\TARGET_Freescale\TARGET_MKL26Z;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MKL26Z;..\..\..\shared\rtos;..\..\target\hal\DBG_Freescale\common;..\..\..\shared\cmsis
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MKL26Z\TOOLCHAIN_ARM_STD\MKL26Z4.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MKL26Z/: system_MKL26Z4.c
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MKL26Z/TOOLCHAIN_ARM_STD/: startup_MKL26Z4.s
  group Common
    ../../Common/src/: DAP.c dap_vendor_command.c main.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usbd_user_cdc_acm.c usbd_user_hid.c usbd_user_msc.c version.c serial.c virtual_fs.c target_flash.c intelhex.c
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: usb_config.c
  group HAL-Interface
    ../../interface/hal/TARGET_Freescale/TARGET_MKL26Z/: gpio.c read_uid.c uart.c usbd_MKL26Z4.c usb_config.c
  group HAL-Target
    ../../target/hal/DBG_Freescale/common/: target_reset_Kseries.c
    ../../target/hal/DBG_NordicSemi/DBG_nRF51822AA/: bit_app_config.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c HAL_CM1.c
target kl26z128_mbit_0x5000 (ARM-ADS)
  device: MKL26Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: kl26z128_mbit_0x5000
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --m32combined -o "$L@L.S19" "#L"
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MKL26Z, __RTX
  c include: as above
  asm define: MBED_BOOTLOADER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: as above
target kl26z128_mbit_0x8000 (ARM-ADS)
  device: MKL26Z128xxx4 Freescale Semiconductor
  cpu: as above
  output: kl26z128_mbit_0x8000
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: OFFSET_VTABLE_32K, TARGET_MKL26Z, __RTX
  c include: as above
  asm define: OPENSDA_BOOTLOADER
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  scatter file: as above
