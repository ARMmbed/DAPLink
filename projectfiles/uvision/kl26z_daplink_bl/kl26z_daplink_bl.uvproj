# Keil uVision project kl26z_daplink_bl.uvproj, settings and files
target kl26z_daplink_bl (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: IRAM(0x0-0x0) IRAM2(0x0-0x0) IROM(0x0-0x0) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: +hex
  AfterMake: fromelf --bin $L@L.axf -o $L@L
  c flags: Optim=4 uC99=1
  c misc: --gnu --c99
  c include: ../../../source/common/cmsis-core/freescale/kl26z;  ../../../source/common/hal/freescale/kl26z
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: ../../../source/common/cmsis-core/freescale/kl26z/armcc/kl26z_daplink_bl.sct
  group default
    ../../../source/common/cmsis-core/freescale/kl26z/: system_MKL26Z4.c
    ../../../source/common/hal/freescale/kl26z/: gpio.c read_uid.c uart.c usb_config.c usbd_MKL26Z4.c
  group rtos
    ../../../source/common/rtos/: HAL_CM1.c HAL_CM3.c HAL_CM4.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c RTX_lib.c
  group usb_msc
    ../../../source/common/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../../source/common/endpoints/drag-n-drop/: intelhex.c usbd_user_msc.c virtual_fs.c
  group usb_core
    ../../../source/common/usb/: usb_lib.c usbd_core.c
  group daplink_bl
    ../../../source/daplink_bl/: flash_svc.c main.c RTX_Config.c version.c SVC_Table.s
