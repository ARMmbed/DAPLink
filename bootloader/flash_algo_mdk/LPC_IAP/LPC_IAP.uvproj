# Keil uVision project LPC_IAP.uvproj, settings and files
target LPC1700_IAP_512 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: flash_algo
  c flags: Optim=3
  c define: LPC1700_512
  c include: C:\Keil_MDK_370\ARM\Flash\LPC_IAP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target LPC1700_IAP_256 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\flash_algo.FLM
  c flags: Optim=3
  c define: LPC1700_256
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1700_IAP_128 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\flash_algo.FLM
  c flags: Optim=3
  c define: LPC1700_128
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1700_IAP_64 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\flash_algo.FLM
  c flags: Optim=3
  c define: LPC1700_64
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1700_IAP_32 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\flash_algo.FLM
  c flags: Optim=3
  c define: LPC1700_32
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC1700_IAP_512_MBED_60MHz (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\flash_algo.FLM
  c flags: Optim=3
  c define: LPC1700_512 MBED
  c include: C:\Keil_MDK_370\ARM\Flash\LPC_IAP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC11xx_IAP_32 (ARM-ADS)
  device: LPC1114/102 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\..\..\tools\tmp
  c flags: Optim=3
  c define: LPC11xx_32 MBED
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target LPC8xx_IAP_4 (ARM-ADS)
  device: LPC810M021 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x100003FF) IROM(0-0x0FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: flash_algo
  AfterMake: cmd.exe /C copy flash_algo.axf ..\..\..\tools\tmp
  c flags: Optim=3
  c define: LPC8xx_4 MBED
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x400
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
