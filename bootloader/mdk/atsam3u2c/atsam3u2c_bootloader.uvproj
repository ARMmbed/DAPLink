# Keil uVision project atsam3u2c_bootloader.uvproj, settings and files
target ATSAM3U2C_bootloader (ARM-ADS)
  device: SAM3U2C Atmel
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20080000-0x20083FFF) IROM(0x00080000-0x0009FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ATSAM3U2C_bootloader
  BeforeMake: python ..\..\..\tools\pre_build_script.py
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: __RTX, TARGET_ATSAM3U2C
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\inc;..\..\Common\src;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Atmel\TARGET_ATSAM3U2C;..\..\..\shared\rtos;..\..\..\..\Common\inc
  asm define: MBED_BOOTLOADER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x5000
  memory RVCT9: RAM 0x20000200 size 0x3e00
  memory RVCT10: RAM 0x20080000 size 0x4000
  scatter file: ..\..\..\shared\cmsis\TARGET_Atmel\TARGET_ATSAM3U2C\TOOLCHAIN_ARM_STD\ATSAM3U2C_BTL.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Atmel/TARGET_ATSAM3U2C/: system_SAM3U.c
    ../../../shared/cmsis/TARGET_Atmel/TARGET_ATSAM3U2C/TOOLCHAIN_ARM_STD/: startup_SAM3U.s
  group Common
    ../../Common/src/: flash_svc.c main.c RTX_Config.c SVC_Table.s usb_config.c usbd_user_msc.c version.c
  group HAL
    ../../hal/TARGET_Atmel/TARGET_ATSAM3U2C/: vector_table.c flash_hal.c gpio.c read_uid.c usbd_ATSAM3U2C.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c HAL_CM3.c
