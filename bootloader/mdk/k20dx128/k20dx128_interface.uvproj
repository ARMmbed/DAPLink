# Keil uVision project k20dx128_interface.uvproj, settings and files
target k20dx128_kl05z_mbed_bootloader_if (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_kl05z_if_mbed_bootloader
  AfterMake: $KARM\ARMCC\BIN\FROMELF.EXE --BIN --OUTPUT=".\k20dx128_kl05z_if_mbed.bin" "#L"
  c flags: Optim=3 oTime=1
  c define: OFFSET_VTABLE_20K, TARGET_MK20D5, __RTX, DBG_KL05Z, BOARD_FRDM_KL05Z, INTERFACE_GEN_32KHZ,TARGET_MK20DX
  c include: ..\..\..\shared\USBStack\INC;..\..\Common\src;..\..\Common\inc;..\..\target\hal\DBG_Freescale\DBG_KL05Z;..\..\interface\hal\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos;..\..\..\shared\common\inc;..\..\hal\TARGET_Freescale\TARGET_MK20DX;..\..\hal\TARGET_Freescale\TARGET_MK20DX\C90TFS\drvsrc\include
  asm define: RAM_TARGET
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
  group Common
    ../../Common/src/: main.c board.c serial.c DAP.c dap_vendor_command.c RTX_Config.c semihost.c SVC_Table.s SW_DP.c swd_host.c usb_config.c usbd_user_cdc_acm.c usbd_user_hid.c
    ../../../shared/common/src/: version.c usbd_user_msc.c
  group HAL-Interface
    ../../interface/hal/TARGET_Freescale/TARGET_MK20DX/: gpio.c read_uid.c uart.c usbd_MK20D5.c
  group HAL-Target
    ../../target/hal/DBG_Freescale/common/: target_reset_Kseries.c target_reset_Lseries.c
    ../../hal/TARGET_Freescale/TARGET_MK20DX/: flash.c flash_erase_read_write.c gpio.c read_uid.c usbd_MK20D5.c vector_table.c
    ../../hal/TARGET_Freescale/TARGET_MK20DX/C90TFS/drvsrc/source/: FlashEraseAllBlock.c FlashEraseSector.c FlashInit.c FlashProgramLongword.c FlashCommandSequence.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_core_msc.c usbd_hid.c usbd_msc.c
  group RTX
    ../../../shared/rtos/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
