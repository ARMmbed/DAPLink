# Keil uVision project k20dx128_bootloader.uvproj, settings and files
target k20dx128_bootloader (ARM-ADS)
  device: MK20DX128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) IROM2(0x10000000-0x10007FFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: k20dx128_bootloader
  c flags: Optim=3 oTime=1
  c define: TARGET_MK20D5, __RTX, MKP128_50MHZ
  c include: ..\..\..\shared\cmsis;..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX;..\..\..\shared\rtos\src;..\..\..\shared\rtos\inc;..\..\..\shared\USBStack\src;..\..\..\shared\USBStack\inc;..\..\..\shared\common\inc;..\..\..\flash_algorithms\MKXXX\C90TFS\drvsrc\include;..\..\Common\src;..\..\Common\inc;..\..\hal\freescale\TARGET_MK20DX\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  scatter file: ..\..\..\shared\cmsis\TARGET_Freescale\TARGET_MK20DX\TOOLCHAIN_ARM_STD\MK20D5.sct
  group CMSIS
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/TOOLCHAIN_ARM_STD/: startup_MK20D5.s
    ../../../shared/cmsis/TARGET_Freescale/TARGET_MK20DX/: system_MK20D5.c
  group Common
    ../../../shared/common/src/: mbed_htm.c validate_user_application.c retarget.c virtual_fs.c
    ../../../Shared/Common/src/: usbd_user_msc.c
  group BootloaderCommon
    ../../Common/src/: SVC_Table.s main.c RTX_Config.c usb_config.c board.c
  group Device
    ../../hal/freescale/TARGET_MK20DX/src/: gpio.c flash_erase_read_write.c read_uid.c usbd_MK20D5.c
  group ProgramFlash
    ../../../flash_algorithms/MKXXX/C90TFS/drvsrc/source/: FlashCommandSequence.c FlashEraseSector.c FlashInit.c FlashProgramLongword.c
  group USBStack
    ../../../shared/USBStack/SRC/: usbd_core.c usbd_core_msc.c usbd_msc.c
  group RTX
    ../../../shared/rtos/src/: HAL_CM3.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
